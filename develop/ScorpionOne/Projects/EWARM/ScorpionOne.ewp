# IAR project ScorpionOne.ewp, settings and files
configuration ScorpionOne Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302xC ST STM32F302xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302xC
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Users\icecut\STM32Cube\Repository\STM32Cube_FW_F3_V1.0.0\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Users\icecut\STM32Cube\Repository\STM32Cube_FW_F3_V1.0.0\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\..\Users\icecut\STM32Cube\Repository\STM32Cube_FW_F3_V1.0.0\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\..\..\..\..\..\Users\icecut\STM32Cube\Repository\STM32Cube_FW_F3_V1.0.0\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Users\icecut\STM32Cube\Repository\STM32Cube_FW_F3_V1.0.0\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: ScorpionOne Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Application
    ./: 
  group Application/EWARM
    ../../../../../../../Users/icecut/STM32Cube/Repository/STM32Cube_FW_F3_V1.0.0/Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f302xc.s
  group Application/User
    ../../Src/: gpio.c main.c stm32f3xx_it.c usb_device.c usbd_conf.c usbd_desc.c
  group Drivers
    ./: 
  group Drivers/CMSIS
    ../../../../../../../Users/icecut/STM32Cube/Repository/STM32Cube_FW_F3_V1.0.0/Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../../Users/icecut/STM32Cube/Repository/STM32Cube_FW_F3_V1.0.0/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c
  group Middlewares
    ./: 
  group Middlewares/USB_Device_Library
    ../../../../../../../Users/icecut/STM32Cube/Repository/STM32Cube_FW_F3_V1.0.0/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../../../../../../../Users/icecut/STM32Cube/Repository/STM32Cube_FW_F3_V1.0.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
